<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dvbs2_tx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/amsat/Docker/adv16apsk910.ldpc</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/amsat/Docker/adv16apsk910.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>dtv_dvb_bbheader_bb</key>
<param><key>id</key><value>dtv_dvb_bbheader_bb_0</value></param>
<param><key>rate3</key><value>C9_10</value></param>
<param><key>framesize2</key><value>FECFRAME_NORMAL</value></param>
<param><key>rolloff</key><value>RO_0_20</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvb_bbscrambler_bb</key>
<param><key>id</key><value>dtv_dvb_bbscrambler_bb_0</value></param>
<param><key>rate3</key><value>C9_10</value></param>
<param><key>framesize2</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvb_bch_bb</key>
<param><key>id</key><value>dtv_dvb_bch_bb_0</value></param>
<param><key>rate3</key><value>C9_10</value></param>
<param><key>framesize2</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0</value></param>
<param><key>rate3</key><value>C9_10</value></param>
<param><key>constellation</key><value>MOD_OTHER</value></param>
<param><key>framesize2</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dtv_dvb_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbheader_bb_0</source_block_id><sink_block_id>dtv_dvb_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbscrambler_bb_0</source_block_id><sink_block_id>dtv_dvb_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bch_bb_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
